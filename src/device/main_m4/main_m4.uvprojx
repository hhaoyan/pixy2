# Keil uVision project main_m4.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: pixy_firmware +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1
  c define: CORE_M4 IPC_MASTER PIXY KEIL USE_QRCODE
  c include: .;inc;..\libpixy_m4\inc;..\common\inc;..\..\common\inc;.\src\zbar\include;.\src\zbar\zbar;.\src\zbar\zbar\decoder;.\src\zbar\zbar\qrcode
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\spifi.sct
  group Source Code
    ./src/: analogdig.cpp button.cpp conncomp.cpp i2c.cpp progblobs.cpp progvideo.cpp serial.cpp spi.cpp exec.cpp uart.cpp main_m4.cpp progpt.cpp progline.cpp line.cpp equeue.cpp spi2.cpp
    ../../common/src/: blob.cpp blobs.cpp colorlut.cpp qqueue.cpp
    ../libpixy_m4/: libpixy_m4.lib
    ./src/zbar/zbar/: config.c convert.c decoder.c image.c img_scanner.c scanner.c symbol.c
    ./src/zbar/zbar/decoder/: qr_finder.c ean.c i25.c code39.c code128.c
    ./src/zbar/zbar/qrcode/: bch15_5.c binarize.c isaac.c qrdec.c qrdectxt.c rs.c util.c
target RAM (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: main_m4 +hex
  c flags: Optim=2 v6Lang=1 v6LangP=1
  c define: CORE_M4 IPC_MASTER PIXY KEIL
  c include: ., inc, ..\libpixy_m4\inc, ..\..\common\inc, ..\common\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\ram.sct
software components: CMSIS:CORE 5.0.0
